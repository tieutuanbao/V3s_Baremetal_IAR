# IAR project V3s_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCDefines: V3S
  ICCARM.CCIncludePath2: ..\Lib\Driver\V3s\inc; ..\Lib\Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: V3s_Project.bin
  ILINK.IlinkOutputFile: V3s_Project.out
  ILINK.IlinkIcfFile: v3s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Driver/V3s
    ../Lib/Driver/V3s/src/: clock.c de.c display.c gic.c gpio.c interrupt.c timer.c
  group Source
    ./: cp15.S startupV3s.s
    ../Source/: main.c
